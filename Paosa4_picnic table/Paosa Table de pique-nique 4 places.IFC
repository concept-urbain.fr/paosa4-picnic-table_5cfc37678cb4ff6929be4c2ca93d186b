Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Paosa Table de pique-nique 4 places.IFC
Time: 2020-05-05T07:56:01
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: FR M12 DIN985 A2_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-001_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-002_Default (4)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-LARG-45CM-003_Default
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-LARG-45CM-004_Default (5)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-LARG-45CM-005_Default
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-LONG-55CM-006_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-LONG-55CM-007_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PAO-MUL-TABLE-PICNIC-LARG-45CM-003_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PAO-TABLE-MUL-LARG-75CM-004_Default
In: Default Storey
Material: 0

# IfcBeam: PAO-TABLE-MUL-LARG-75CM-005_Default
In: Default Storey
Material: 0

# IfcBeam: PAO-TABLE-PICNIC-4P-003_Default
In: Default Storey
Material: 0

# IfcBeam: PAO-TRESPA-MUL-45X55-001_Default (3)
In: Default Storey
Material: Trespa

# IfcBeam: PROTO-PAO-TAB-BAS-MUL-003_Default (2)
In: Default Storey
Material: 0

# IfcBeam: PROTO-PAO-TAB-BAS-MUL-004_Default (3)
In: Default Storey
Material: 0

# IfcBeam: ROND-M12-A2_Default (2)
In: Default Storey
Material: 0

# IfcBeam: SYM-PAO-MUL-TABLE-PICNIC-LONG-55CM-005_Default
In: Default Storey
Material: 0

# IfcBeam: TBHC-M12x30-A2_Default (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: FR M12 DIN985 A2_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-001_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-002_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-LARG-45CM-003_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-LARG-45CM-004_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-LARG-45CM-005_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-LONG-55CM-006_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-LONG-55CM-007_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-TABLE-PICNIC-LARG-45CM-003_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-MUL-TABLE-PICNIC-LONG-55CM-005_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TABLE-MUL-LARG-75CM-003_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TABLE-MUL-LARG-75CM-004_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TABLE-MUL-LARG-75CM-005_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TABLE-MUL-LONG-70CM-005_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TABLE-PICNIC-4P-003_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PAO-TRESPA-MUL-45X55-001_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Trespa

# IfcBuildingElementProxy: PAO-TRESPA-MUL-75X140-001_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Trespa

# IfcBuildingElementProxy: PROTO-PAO-TAB-BAS-MUL-003_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PROTO-PAO-TAB-BAS-MUL-004_Default (5)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ROND-M12-A2_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SYM-PAO-MUL-TABLE-PICNIC-LONG-55CM-005_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TBHC-M12x30-A2_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
